Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2022-09-12T16:05:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 12 16:05:06 2022 * Host: MOD1 * Database: C:\Users\FCHAVE~1.BIM\AppData\Local\Temp\318d3f31-1241-4e31-bdc5-0170a5e9b2af\bad9a0a4-f5f5-4b05-8120-6e5c19d673bd\ifc * Database version: 5507 * Database creation date: Mon Sep 12 16:05:05 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 12 16:05:05 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 12 16:05:05 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: FR - 100 VJR:100 VJR, FR - 100 VJR:100 VJR:13742
In: Level 1
Type - Material: Par défaut
Type - Constraints - Capacité de la nacelle: 200 kg; Default Elevation: 0 mm; Déport du contrepoids avec tourelle à 90°: 90 mm; Déport max: 3150 mm; Dévers autorisé: 2 deg; Hauteur de levage max: 9850 mm
Type - Construction - Consommation moyenne: 0 m3/s; Unloaded Weight: 2650 kg
Type - Data - Empattement: 1200 mm; Garde au sol: 90 mm; Garde au sol au centre de l'empattement: 90 mm; Hauteur hors tout repliée: 1990 mm; Hauteur plancher: 510 mm; Hauteur position transport: 1995 mm; Largeur: 990 mm; Largeur du panier: 930 mm; Longueur du panier: 1110 mm; Longueur hors tout repliée: 2800 mm; longueur pendulaire: 1500 mm; Longueur position transport: 2810 mm; Nombre de personne (Extérieur): 1; Nombre de personne (Interieur): 2; Norme du moteur: Directives Européennes : 2006/42/CE - Machines (refonte EN280-2013) - 2004/108/EC (EMC) - 2006/95/CE (Basse tension); Norme moteur: A préciser; Poids de la nacelle: 2650 kg; Rayon de giration 4RD ext: 2090 mm; Rayon de giration 4RD int: 590 mm; Surplomb: 6670 mm
Type - Dimensions - Floor Height: 510 mm; Max Offset: 3150 mm; Overall height: 1990 mm; Overall length: 2800 mm; Overall width: 990 mm
Type - Energy Analysis - Consommation moyenne (L/h): 0; Puissance du moteur I.C. (ch): 0; Puissance du moteur I.C. (kW): 1.5
Type - Green Building Properties - CO2: 0
Type - Identity Data - BC_MODEL_ID: 760620; BC_OBJECT_ID: 213442; BC_OBJECT_VERSION: #1; BC_VARIANT_ID: 522371; Créé par: ATLANCAD; Manufacturer: MANITOU; Manufacturer Product Link: https://www.manitou.com/fr-FR/nos-machines/nacelles-elevatrices/100-vjr; Model: 100 VJR; Object type: Electric articulated work platform; OmniClass Number: 23.50.00.00; OmniClass Title: Conveying Systems & Material Handling; Reference: 100 VJR; Type Name: 100 VJR; URL: www.manitou.fr
Type - Other - Category: Specialty Equipment; Bruit à l'environnement (LwA) en dB(A): 0; Consommation carburant (l/jour): 0 mm; Emissions de CO2 (g/kWh): 0; Family Name: FR - 100 VJR; MasterFormat: Operation and Maintenance of Transportation; Masterformat Code: 34 01 00; Maximum Load Supported (Fork or Pod): 200 kg; Max Number of People: 2; Max Working Height: 9850 mm; OmniClass code: 23-23 00 00; OmniClass description: Conveying Systems and Material Handling Products; Rated motor power: 1500 W; Turning Radius: 2090 mm; Uniformat: Autres systèmes transporteurs; Uniformat code: D1090
Type - Pset_BuildingElementProxyCommon - Reference: 100 VJR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MANITOU
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 100 VJR
Material: Par défaut, 60_60_60, Roues_100VJR_255_250_240, Roues_191 191 191, Tolerie_60_60_60, Carrosserie 255_0_0, Rouge Manitou, Acier Noir, <Unnamed>
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm; R2: 0 deg
Dimensions - Abaque Visible: yes; Angle Panier Souhaité: -50 deg; Area: 16.6309 m2; Débord Réel: 2018.41 mm; Hauteur Mat téléscopique Souhaitée: 2000 mm; Hauteur Plancher Panier Réelle: 887.703 mm; Rayon de Giration Visible: yes; Réglage du Pendulaire: yes; Rotation Tourelle / Chassis: 0 deg; Volume: 1.32946 m3
Other - Family: FR - 100 VJR: 100 VJR; Family and Type: FR - 100 VJR: 100 VJR; Type: FR - 100 VJR: 100 VJR; Type Id: FR - 100 VJR: 100 VJR
Phasing - Phase Created: New Construction
